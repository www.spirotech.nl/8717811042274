Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Vessel_EP1500R_INT-EN.ifc
Time: 2025-08-05T18:20:23+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcBuildingElementProxy: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Vessel_INT-EN:EP1500R, HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Vessel_INT-EN:EP1500R:1783900
In: F00
Type - Material: Color RAL 1003, Color RGB 040-040-040
Type - Other - Category: Mechanical Equipment; Bracket Visibility: no; Bracket Visibility 2: no; Connection Geometry: Connection_Geometry : EP1500R(S); Connection Visibility: no; Connection Visibility 2: no; Connection Visibility 3: no; Connection Visibility 4: no; Connection Visibility 5: no; Connector Angle: 270 deg; Drain Geometry: yes; Drain Geometry 2: no; Drain Geometry 3: yes; Drain Position-Back: 425.32 mm; Drain Position-Elevation: 1712 mm; Drain Position-Right: 425.32 mm; Drain Revolve Start Angle: -2 deg; EP0200R(S) Expansion Vessel: no; EP0300R(S) Expansion Vessel: no; EP0500R(S) Expansion Vessel: no; EP0800R(S) Expansion Vessel: no; EP1000R(S) Expansion Vessel: no; EP1500R(S) Expansion Vessel: yes; EP2000R(S) Expansion Vessel: no; EP2500R(S) Expansion Vessel: no; EP3000R(S) Expansion Vessel: no; EP4000R(S) Expansion Vessel: no; EP5000R(S) Expansion Vessel: no; EPX100R(S) Expansion Vessel: no; Family Name: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Vessel_INT-EN; Feet Geometry: Feet_Geometry : EP1500R(S); Nominal Diameter: 31.75 mm; Outer Diameter: 42.4 mm; Upper Geometry: yes; X Axis: 441 mm; Y Axis: 133.63 mm; Z Axis: 139.06 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Diameter: 31.75 mm; Diameter: 1050 mm; Drain Diameter: 50 mm; Height: 2220 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Primary Expansion vessels for EMCM & ETCM 1500 ltr; Article Type: EP1500R; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Primary Expansion vessels for EMCM & ETCM 1500 ltr; EMCS Version: 4.0; ETIM Article Class: EC010958; Family Version: 12.24; GLN: 8717811000007; GTIN: 8717811042274; Manufacturer: Spirotech; Manufacturer Art. No.: EP1500R; Manufacturer URL: https://www.spirotech.com/8717811042274; MEPcontent Class: EXPANSIONVESSEL; Model: EP1500R; OmniClass Number: 23.75.70.11.14; OmniClass Title: Expansion Vessels; Product Line: Spirotech; Revit Version: 2023; Type Name: EP1500R; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Color: Color RAL 1003
Type - Mechanical - Max. Medium Temperature (continuous): 0 C; Pre-pressure: 0; Volume: 1.5 m3
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_BuildingElementProxyCommon - Reference: EP1500R; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: EP1500R
Other - Family: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Vessel_INT-EN; Family and Type: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Vessel_INT-EN: EP1500R; Type: EP1500R; Type Id: 1783856
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 76.341 m2; Volume: 1.49124 m3
Identity Data - Mark: 4
Mechanical - Flow 1: 0 m3/s; Flow 2: 0 m3/s; System Classification: Undefined,Sanitary
Mechanical - Flow - Drain Fixture Units: 0
Phasing - Phase Created: 3. New Construction

# IfcDistributionPort (3)
Description: Flow; PredefinedType: PIPE
Name | FlowDirection
OutPort_1783900_1 | SOURCE
InPort_1783900_2 | SINK
OutPort_1783900_3 | SOURCE | SystemType: SEWAGE
